# Keil uVision project Template_EIDE.uvprojx, settings and files
target Template_EIDE (6150000::V6.15::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template_EIDE
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: Libraries/STM32F10x_StdPeriph_Driver/inc;Libraries/CMSIS/CM3/CoreSupport;user/inc;Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x;.eide/deps;Libraries/smarttimer;.eide/deps;Middleware/TaskManager;user/src
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER/SRC
    user/src/: beep.c LED.c main.cpp stm32f10x_it.c
  group StartCode
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group SMSIS
    user/: system_stm32f10x.c
  group Middleware/TaskManager
    Middleware/TaskManager/: systime.c taskmanager.cpp
  group FWLib
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c
